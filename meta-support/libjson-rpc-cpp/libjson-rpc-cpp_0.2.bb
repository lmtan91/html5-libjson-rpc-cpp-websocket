require libjson-rpc-cpp.inc
